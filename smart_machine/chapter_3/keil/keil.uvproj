# Keil uVision project keil.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: keil
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../: chapter_3.c chapter_3.h font_library.h utils.c key_function.c diaplay_function.c calculate.c
